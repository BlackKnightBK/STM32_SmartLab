# Keil uVision project IO.uvprojx, settings and files
target IO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\USER\LED;.\USER\KEY;.\USER\Delay;.\USER\TIM;.\USER\USART;.\USER;.\USER\HC-SR04;.\USER\DHT11;.\USER\IIC;.\USER\OLED;.\USER\SPI;.\USER;.\USER\RTC;.\USER\ADC;.\StdPeriph\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c
    ./USER/LED/: led.c
    ./USER/KEY/: key.c
    ./USER/Delay/: delay.c
    ./USER/TIM/: tim.c
    ./USER/USART/: usart.c
    ./USER/HC-SR04/: hcsr04.c
    ./USER/DHT11/: dht11.c
    ./USER/IIC/: iic.c
    ./USER/OLED/: oled.c
    ./USER/SPI/: spi.c
    ./USER/RTC/: rtc.c
    ./USER/ADC/: adc.c
  group Stdperiph
    ./StdPeriph/src/: stm32f4xx_adc.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
